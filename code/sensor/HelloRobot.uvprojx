# Keil uVision project HelloRobot.uvprojx, settings and files
target Hello Robot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HelloRobot +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\core;.\user;.\lib\inc;.\op;.\System;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ./core/: core_cm3.c startup_stm32f10x_hd.s
  group lib
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: Delay.c Delay.h Util.c Util.h MyRTC.c MyRTC.h Timer.c Timer.h
  group Hardware
    ./Hardware/: Key.c Key.h LED.c LED.h OLED.c OLED.h OLED_Font.h MPU6050.c MPU6050.h MPU6050_Reg.h
  group user
    ./user/: system_stm32f10x.c main.c stm32f10x_it.c adc.c
software components: CMSIS:CORE 5.6.0
